# Keil uVision project final_project.uvproj, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: usbaudio +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\common\inc;.\common\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  scatter file: .\DMA.sct
  group Source Files
    ./: usbuser.c usbcore.c usbdesc.c usbdmain.c usbhw.c adcuser.c Font_6x8_h.h Font_16x24_h.h game_logic.c game_logic.h GLCD.h GLCD_SPI_LPC1700.c KBD.c KBD.h main.c LPC17xx.h usbdmain.h photo_viewer.c photo_viewer.h
  group Startup Files
    ./: system_LPC17xx.c core_cm3.c startup_LPC17xx.s
  group resources
    ./: Bg_16bpp_t.c cat.c kyogre.c
